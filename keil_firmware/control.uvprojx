# Keil uVision project control.uvprojx, settings and files
target 三棒签插签设备 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0x8-0xFF) IROM(0x0-0x1FFF) CLOCK(11059200) MODP2
  output: control +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: main.c
